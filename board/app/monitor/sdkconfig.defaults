## board/app/monitor/sdkconfig.defaults
```kconfig
# M5Stack Core
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
CONFIG_BOOTLOADER_COMPILER_OPTIMIZATION_SIZE=y

# LVGL
# CONFIG_LV_BUILD_EXAMPLES is not set
```
